# Keil uVision project Prog.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Prog +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: .\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Device\ST\STM32F4xx\Source\Templates;.\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\CMSIS;.\sources;.\Freemaster
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
  group user
    ./user/: config.h UNIT_FREEMASTER_UART.c UNIT_FREEMASTER_UART.h main.c include.h timer_2.c timer_2.h timer_1.c timer_1.h timer_8.c timer_8.h timer_3.c timer_3.h timer_4.c timer_4.h timer_5.c timer_5.h adc.c adc.h timer_6.c timer_6.h can_1.c can_1.h timer_9.c timer_9.h
  group Freemaster
    ./Freemaster/: PE_freemaster.h PE_freemaster_56F8xxx.c PE_freemaster_56F8xxx.h PE_freemaster_appcmd.c PE_freemaster_cfg.h PE_freemaster_fastrec.c PE_freemaster_fastrec.h PE_freemaster_private.h PE_freemaster_protocol.c PE_freemaster_protocol.h PE_freemaster_rec.c PE_freemaster_rec.h PE_freemaster_scope.c PE_freemaster_serial.c PE_freemaster_sfio.c PE_freemaster_tsa.c PE_freemaster_tsa.h
  group SPL
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group CMIS
    ./CMSIS/: stm32f4xx_conf.h system_stm32f4xx.c
    ./CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./CMSIS/Include/: core_cm4.h
software components: CMSIS:CORE 5.4.0
