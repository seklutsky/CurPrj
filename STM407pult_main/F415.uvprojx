# Keil uVision project F415.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pult +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: .\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Device\ST\STM32F4xx\Source\Templates;.\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\CMSIS;.\sources;.\Freemaster;.\user;.\user\displey
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ./user/: main.c timer_2.c timer_2.h include.h adc.c adc.h config.h UNIT_FREEMASTER_UART.c UNIT_FREEMASTER_UART.h UNIT_I2C.c UNIT_I2C.h UNIT_SPI.c UNIT_SPI.h timer_4_inc.c timer_4_inc.h display.c display.h dac.c dac.h encoder.c encoder.h pwm.h pwm.c run.c run.h gpio_init.c gpio_init.h temperature.c temperature.h math_func_log.c math_func_log.h var.h can_1.c can_1.h buttons.c buttons.h
  group CMSIS
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c
    ./CMSIS/: stm32f4xx_conf.h system_stm32f4xx.c
    ./CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./CMSIS/Include/: core_cm4.h
    ./STM32F4xx_StdPeriph_Driver/inc/: misc.h
  group SPL
    ./STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_rtc.h stm32f4xx_rcc.h stm32f4xx_gpio.h stm32f4xx_usart.h stm32f4xx_tim.h stm32f4xx_can.h stm32f4xx_adc.h stm32f4xx_i2c.h stm32f4xx_spi.h stm32f4xx_dac.h
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_can.c stm32f4xx_adc.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_dac.c
  group FreeMaster
    ./Freemaster/: PE_freemaster.h PE_freemaster_56F8xxx.c PE_freemaster_56F8xxx.h PE_freemaster_appcmd.c PE_freemaster_cfg.h PE_freemaster_fastrec.c PE_freemaster_fastrec.h PE_freemaster_private.h PE_freemaster_protocol.c PE_freemaster_protocol.h PE_freemaster_rec.c PE_freemaster_rec.h PE_freemaster_scope.c PE_freemaster_serial.c PE_freemaster_sfio.c PE_freemaster_tsa.c PE_freemaster_tsa.h
  group Display
    ./user/displey/: disp1color.c disp1color.h f6x8m.c f6x8m.h f10x16f.c f10x16f.h spim.c spim.h ssd1306.c ssd1306.h delay.h delay.c types.h gpio.c gpio.h font.c font.h i2cm.c i2cm.h
software components: CMSIS:CORE 5.0.1
